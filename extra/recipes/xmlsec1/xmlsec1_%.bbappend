PR .= ".1"

do_install_class-native () {
	autotools_do_install
	exit 0
}
