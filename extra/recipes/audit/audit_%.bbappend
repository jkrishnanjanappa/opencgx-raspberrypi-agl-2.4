DEPENDS += "swig-native"
